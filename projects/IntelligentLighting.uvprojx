# Keil uVision project IntelligentLighting.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IntelligentLighting
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\cmsis;..\src\human;..\src\led;..\src\light;..\src\lora;..\src\nvic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../cmsis/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group src
    ../src/: main.c
    ../src/lora/: lora.c uart.c lora.h
    ../src/light/: light.c light.h
    ../src/led/: led.c pwm.c
    ../src/human/: human.c timer.c timer.h
    ../src/nvic/: nvic.c
